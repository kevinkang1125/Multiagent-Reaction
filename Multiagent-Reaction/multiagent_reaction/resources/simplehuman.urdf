Commit message: Initial

File: Multiagent-Reaction/multiagent_reaction/resources/simplehuman.urdf (robot description, URDF)
Before this commit: robot simplegoal, 1 links, 0 joints
Links:
- link base_link: geometry collision cylinder length=0.5 radius=0.25; visual cylinder length=1.75 radius=0.25
