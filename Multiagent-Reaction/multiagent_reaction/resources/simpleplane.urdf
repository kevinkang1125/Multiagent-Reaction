Commit message: Init

File: Multiagent-Reaction/multiagent_reaction/resources/simpleplane.urdf (robot description, URDF)
Before this commit: robot simpleplane, 1 links, 0 joints
Links:
- link base_link: geometry collision box size=400 400 0.01; visual box size=400 400 0.01
